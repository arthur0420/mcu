# IAR project Uart3.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207C8 STM8S207C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207C8
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Uart3.hex
  ILINK.IlinkOutputFile: Uart3.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    ../FWlib/src/: stm8s_adc2.c stm8s_clk.c stm8s_uart3.c
    ../../STM8（Axx）_例程/STM8S-A04_UART基本收发数据/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_gpio.c
    ../../STM8（Axx）_例程/STM8S-A02_TIM精确延时（阻塞式）/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_tim4.c
  group USER
    ../USER/: bsp_timer.c main.c stm8s_interruput.c uart.c
